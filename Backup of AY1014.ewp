# IAR project Backup of AY1014.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F102A8 RL78 - R5F102A8
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_cg_timer.c r_cg_timer_user.c r_cg_wdt.c r_cg_wdt_user.c
