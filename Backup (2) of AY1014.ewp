# IAR project Backup (2) of AY1014.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenDeviceSelect: R5F102A8 RL78 - R5F102A8
  ICCRL78.IccLang: 0
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.CCDefines: NDEBUG
  XLINK.XlinkExtraOptions: -Ointel-extended,(CODE)=.code.hex
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f102a9.xcl
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_cg_timer.c r_cg_timer_user.c r_cg_wdt.c r_cg_wdt_user.c
